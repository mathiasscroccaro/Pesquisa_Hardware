# Repository mathiasscroccaro/Pesquisa_Hardware

File README.md:

# Master degree schematics folder

At the root of this directory you will find some projects developed at my master degree at UNICAMP. Each one is classified from a project to another.

## IV Measurement (Kicad 4.0)

Design of a single cell I-V measurement circuit.

## High Speed Op. Amp. Socket (Kicad 4.0)

Design of a socket for Gansil GS8051 op. amp.

## Low Voltage DC-DC

Designs for DC-DC with at least 0,8 V for cold start.

The initial problem of this kind of circuit is the leakage current and the high switching frequency. The tricky point for correctly assemble the system is the inductors and capacitors selection: Inductos with low series resistance (<0.1 Ohm) and capacitors XR7. It's all about energy loss. All resistive component makes loss. Not only, some layout strategies may count for better performance. The preference is to keep elements of the circuit close to the IC, avoiding EMC, tracks resistance and noise at the feedback pins. 

### MP3414 (Kicad 4.0)

Low cost (US$0,2 at LCSC.com) Step-up converter

### BQ25504 (Kicad 4.0)

High cost (US$4,6 at ti.com) Energy Harvesting Power Management IC 

## NRF51822 Socket (Kicad 5.0)

This project is a simple socket for NRF51822 radio uC. The schematics includes programming pins, one led and a trimpot for analog read signals.

## KiCad design nrf51822_socket/nrf51822socket.kicad_pcb

Parts:
C1: 100nF; CP_Radial_D5.0mm_P2.50mm
D1: LED; LED_D3.0mm
J1: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Vertical
J2: Esquerdo; PinSocket_2x09_P2.00mm_Vertical
J3: Direito; PinSocket_2x09_P2.00mm_Vertical
J4: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical
Q1: Q_NMOS_GSD; SOT-23
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2: R_POT_TRIM_US; Potentiometer_Bourns_3296W_Vertical
SW1: SW_Push_Dual; SW_TH_Tactile_Omron_B3F-10xx

Connections:
+2V5: D1.2 (A), J1.2, J2.12, J4.6, R3.1
/01: J2.16, RV1.2
/02: J2.15, R1.1
/04: C1.1, J2.17, R3.2, SW1.1
GND: C1.2, J2.2, J2.11, J4.5, Q1.2 (S), RV1.3, RV2.3, SW1.4
unnamed: D1.1 (K), R2.1
unnamed: J1.1, RV1.1, RV2.1
unnamed: J2.18, RV2.2
unnamed: Q1.1 (G), R1.2
unnamed: Q1.3 (D), R2.2
RX: J3.17, J4.1
SWCLK: J3.5, J4.4
SWDIO: J3.6, J4.3
TX: J3.18, J4.2

Notes on the sheet:
Release notes: v 0.1 - First schematic, with LDO circuit; v 0.2 - Include jumpers at power supply of timpot resistor divider; - Include push buttom at analog/GPIO pin; - Removed LDO circuit;

Board: 2 copper layers, 13 parts (3 on the bottom side), 14 nets.

## KiCad design low_current_amplifier/low_current_amplifier.kicad_pcb

Parts:
C1, C2: C_Small; CP_Radial_D6.3mm_P2.50mm
J1, J2: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical
J3, J4, J5: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
R1, R2, R3, R5, R7, R9: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R6, R8: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10: Rshunt; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: LN1134; SOT-23-5

Connections:
+1: J1.3, J3.2, R10.1
+2: C2.1, J1.5, J4.2, R1.1, R6.2, R8.2, R10.2, U1.5 (OUT)
+3: J1.7, J2.5, J5.1, R5.1
+4: J2.3, J2.7, J5.2, R7.1
+5V: C1.1, J1.4, J3.1, J4.1, U1.1 (IN), U1.3 (EN)
-1: J1.2, R1.2, R2.2, R4.2
-2: J1.6, R3.1, R4.1, R5.2
-3: J2.6, R6.1, R7.2
-4: J2.2, R8.1, R9.2
GND: C1.2, C2.2, J2.4, J3.3, J4.3, U1.2 (GND)
OUT1: J1.1, R2.1, R3.2
OUT4: J2.1, J5.3, R9.1

Board: 2 copper layers, 18 parts (10 on the bottom side), 12 nets.

## KiCad design LowVoltageDCDC/bq25570/bq25570.kicad_pcb

Parts:
C1: >4.7uF
C2, C3: 100nF
C4, C6: 22uF
C5: 22 uF
J1: Ligar_bucker
J2: Bateria
J3: Saida
J4: Entrada
L1: 22uH
L2: 10uH
Rok1, Rok2, Rok3: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Rout1, Rout2: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Rov1, Rov2: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: bq25570

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J2.2, J3.4, J4.2, Rok1.2, Rout1.2, Rov1.2, U1.1 (Vss), U1.5 (~EN), U1.15 (Vss); also elsewhere on the board
unnamed: C3.1, U1.4 (Vref_SAMP)
unnamed: C6.1, J2.1, U1.18 (VBAT)
unnamed: J1.1, U1.6 (Vout_EN)
unnamed: L1.2, U1.20 (LBOOST)
unnamed: L2.1, U1.16 (LBUCK)
unnamed: Rok1.1, Rok2.2, U1.11 (OK_PROG)
unnamed: Rok2.1, Rok3.2, U1.10 (OK_HIST)
unnamed: Rok3.1, Rout2.1, Rov2.1, U1.8 (VRDIV)
unnamed: Rout1.1, Rout2.2, U1.12 (Vout_SET)
unnamed: Rov1.1, Rov2.2, U1.7 (Vbat_OV)
Vbat_OK: J3.3, U1.13 (Vbat_OK)
Vin: C1.1, J4.1, L1.1, U1.2 (Vin_DC); also elsewhere on the board
Vout_boost: C2.1, C4.1, J1.2, J3.2, U1.3 (Voc_SAMP), U1.19 (VSTOR)
Vout_buck: C5.1, J3.1, L2.2, U1.14 (Vout)

Board: 2 copper layers, 21 parts (0 on the bottom side), 15 nets.

Other parts of the board:
J5: Entrada; PinSocket_1x02_P2.54mm_Vertical

Their connections:
GND: J5.2; also elsewhere on the board
Vin: J5.1; also elsewhere on the board

## KiCad design LowVoltageDCDC/ChineseDCDC/ChineseDCDC.kicad_pcb

Parts:
C1: 10uF; C_1206_HandSoldering
C2, C3: 0.1uF; C_0805_HandSoldering
C4: 47uF; C_1206_HandSoldering
C5, C6, C7: 1uF; CP_Radial_D8.0mm_P5.00mm
C8: 1-2.2uF; CP_Radial_D8.0mm_P5.00mm
J1, J2: Conn_01x02; TerminalBlock_Altech_AK300-2_P5.00mm
J3, J4, J6, J7: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm
J5: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
L1: 3.3uH; L_Taiyo-Yuden_NR-60xx_HandSoldering
R1: 100k; R_1206_HandSoldering
R2: 365k; R_0805_HandSoldering
R3: 210k; R_0805_HandSoldering
U1: MP3414; SOT-23-8_Handsoldering
U2: SC6206B - SHEN ZHEN; SOT-23
U3: LN1134 - NATLINEAR; SOT-23-5_HandSoldering

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.1, J2.2, J4.1, J5.1, J6.2, J7.2, R3.2, U1.4 (PGND), U1.6 (AGND), U2.1 (GND), U3.2 (GND)
unnamed: C5.1, J4.2, U2.3 (VI)
unnamed: C6.1, J5.2, U3.1 (VIN)
unnamed: C7.1, J6.1, U2.2 (VO)
unnamed: C8.1, J7.1, U3.5 (VOUT)
unnamed: J3.2, R1.2
unnamed: J5.3, U3.3 (EN)
unnamed: L1.2, U1.3 (SW)
unnamed: R1.1, U1.8 (EN)
unnamed: R2.2, R3.1, U1.7 (FB)
Vin: C1.1, C2.1, J1.2, J3.1, L1.1, U1.1 (IN)
Vout: C3.1, C4.1, J2.1, R2.1, U1.2 (OUT)

Board: 2 copper layers, 22 parts (0 on the bottom side), 12 nets.

## KiCad design LowVoltageDCDC/bq25504/bq25504.kicad_pcb

Parts:
BT1: Battery_Cell; Keystone_106_1x20mm-CoinCell
C1: SuperCap; CP_Radial_Tantal_D10.5mm_P5.00mm
C_bypass_out1: 100 nF; C_0805_HandSoldering
C_in1: 10 uF; C_1206_HandSoldering
C_out1: 22 uF; C_1206_HandSoldering
C_vref_samp1: 100 nF; C_0805_HandSoldering
J1: Conn_01x02; TerminalBlock_Altech_AK300-2_P5.00mm
J2: Conn_01x03; TerminalBlock_Altech_AK300-3_P5.00mm
J3: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm
L1: 22 uH; L_Taiyo-Yuden_NR-60xx_HandSoldering
Roc1: 15M; R_0603_HandSoldering
Roc2: 4M; R_0603_HandSoldering
Rok1: 5.95M; R_0603_HandSoldering
Rok2: 3.57M; R_0603_HandSoldering
Rok3: 0.47M; R_0603_HandSoldering
Rov1: 5.9M; R_0603_HandSoldering
Rov2: 2M; R_0603_HandSoldering
Ruv1: 5.9M; R_0603_HandSoldering
Ruv2: 2.5M; R_0603_HandSoldering
U1: BQ25504; UQFN-16-1EP_3x3mm_Pitch0.5mm

Connections:
Battery: J3.1, U1.14
DigitalOutput: J2.1, U1.11
GND: BT1.2 (-), C1.2, C_bypass_out1.2, C_in1.1, C_out1.2, C_vref_samp1.2, J1.1, J2.3, Roc1.2, Rok1.2, Rov1.2, Ruv1.2, U1.1, U1.5, U1.12, U1.13
unnamed: BT1.1 (+), C1.1, J3.2
unnamed: C_vref_samp1.1, U1.4
unnamed: L1.2, U1.16
unnamed: Roc1.1, Roc2.2, U1.3
unnamed: Rok1.1, Rok2.2, U1.10
unnamed: Rok2.1, Rok3.2, U1.9
unnamed: Rok3.1, Rov2.1, Ruv2.1, U1.7
unnamed: Rov1.1, Rov2.2, U1.6
unnamed: Ruv1.1, Ruv2.2, U1.8
Vin: C_in1.2, J1.2, L1.1, Roc2.1, U1.2
Vout: C_bypass_out1.1, C_out1.1, J2.2, U1.15

Notes on the sheet:
Tensão de regulação: Vbat_ov = 3/2 * 1.25 * (1 + 2M/5.9M) = 2,5 V Tensão de hysteresis = 2,1 V Tensão VBAT_ok = 2,0 V Tensão de undervoltage: Vbat_uv = (1 + 1M/5.9M) = 1,8 V

Board: 2 copper layers, 20 parts (2 on the bottom side), 14 nets.

## KiCad design IVmeasurement/IVmeasurement_v0.4/IVmeasurement.kicad_pcb

File IVmeasurement/README.md:

# IV measurement versions

v0.1 to v0.4 were made with Kicad 4.0.

Article version was made with Kicad 5.0

Schematic: IVmeasurement.sch, IV measurement

Parts:
C2: 100nF; CP_Radial_D5.0mm_P2.50mm
J1: DAC; Pin_Header_Straight_1x01_Pitch2.54mm
J2: Sollar Cell; TerminalBlock_bornier-2_P5.08mm
J3, J4, J5: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
J6: Source; Pin_Header_Straight_1x02_Pitch2.54mm
J7: Vref; Pin_Header_Straight_1x01_Pitch2.54mm
J8, J10: Conn_01x07; Pin_Header_Straight_1x07_Pitch2.54mm
J9: ADC; Pin_Header_Straight_1x02_Pitch2.54mm
J11: Vgs; Pin_Header_Straight_1x01_Pitch2.54mm
J12: G11; Pin_Header_Straight_1x03_Pitch2.54mm
J13: G101; Pin_Header_Straight_1x03_Pitch2.54mm
J14: G1001; Pin_Header_Straight_1x03_Pitch2.54mm
Q1: IRF540N; TO-220-3_Vertical
R1: 1M; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R2: 100k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R3: 10k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R4: 1k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R5: Shunt; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R6: 470; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R7, R10: 4.7k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R8: 47k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R9: 470k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R11: 2.2k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
Vshunt1: Vshunt; Pin_Header_Straight_1x01_Pitch2.54mm
Vsolar+1: Vsolar+; Pin_Header_Straight_1x01_Pitch2.54mm

Connections:
+1: J3.3, J4.3, J5.3, J7.1, J8.3, R4.2
+2: J2.1, J8.5, Q1.2 (D)
+3: J8.2, J10.5, Q1.3 (S), R5.1, Vshunt1.1
+5V: C2.2, J6.2, J8.4
-2: J8.6, R10.1, R11.2
-3: J10.6, J12.1, J13.1, J14.1, R6.1, R7.1, R8.1, R9.1
ADC1: J8.7, J9.1, R11.1
ADC2: J9.2, J10.7, J12.3, J13.3, J14.3
DAC1: J1.1, J3.1, J4.1, J5.1, R1.2, R2.2, R3.2
GND: C2.1, J2.2, J6.1, J10.4, R4.1, R5.2, R6.2, R10.2
unnamed: J3.2, R1.1
unnamed: J4.2, R2.1
unnamed: J5.2, R3.1
unnamed: J12.2, R7.2
unnamed: J13.2, R8.2
unnamed: J14.2, R9.2
Out1: J8.1, J11.1, Q1.1 (G)

Notes on the sheet:
Voltage measure. Gain = 1.46 V/V
Current measure. Gain = [ 11, 101, 1001 ] V/V
Input reference current. Iref = [ 3.3 33.3 333.3 ] A

Board: 2 copper layers, 58.4 x 50.8 mm, 28 parts (1 on the bottom side), 17 nets.

## KiCad design IVmeasurement/IVmeasurement_v0.1/IVmeasurement.kicad_pcb

Board: 2 copper layers, 175.3 x 63.5 mm, 39 parts (0 on the bottom side), 29 nets.

Parts:
C1, C2: 100nF; CP_Radial_D5.0mm_P2.50mm
J1, J4, J5, J6, J11, J12, J13: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
J2: Sollar Cell; TerminalBlock_bornier-2_P5.08mm
J3: DAC; Pin_Header_Straight_1x02_Pitch2.54mm
J7: Test VGS; Pin_Header_Straight_1x01_Pitch2.54mm
J8, J10: Conn_01x07; Pin_Header_Straight_1x07_Pitch2.54mm
J9: ADC; Pin_Header_Straight_1x02_Pitch2.54mm
J14: Source; Pin_Header_Straight_1x03_Pitch2.54mm
J15: Test VDS; Pin_Header_Straight_1x01_Pitch2.54mm
J16: baixo; Pin_Header_Straight_1x03_Pitch2.54mm
J17: cima; Pin_Header_Straight_1x03_Pitch2.54mm
J18: baixo; Pin_Header_Straight_1x02_Pitch2.54mm
J19: cima; Pin_Header_Straight_1x02_Pitch2.54mm
Q1: IRF9540N; TO-220-3_Vertical
R1, R6: 1M; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R2, R7, R14: 100k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R3: 7.1k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R4, R15: 51k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R5: 609; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R8: 60; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R9: 10k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R10: 23k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R11: 320k; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R12: 100; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R13: R; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
U1: INA128; DIP-8_W7.62mm_Socket_LongPads
U2: LM324; DIP-14_W7.62mm_LongPads

Connections:
5v: J16.3, J17.3, U2.4
+1: J3.1, J8.3
+2: J8.5, R6.2, R7.1
+3: J2.2, J10.5, R13.1, U1.3
+3V3: C1.2, J14.2, U1.7
+5V: C2.2, J8.4, J14.3
-1: J8.2, R2.2, R4.1
-2: J7.1, J8.6, J8.7, Q1.1
-3: J10.6, J11.3, J12.3, J13.3, R9.2, R10.1, R11.1, R12.1
ADC1: J9.1, U1.6
ADC2: J9.2, J10.7, J11.1, J12.1, J13.1
DAC2: J3.2, R6.1
unnamed: J1.1, J4.1, J5.1, J6.1, R1.2, R3.2, R5.2, R8.2, U1.8
unnamed: J1.2, R1.1
unnamed: J1.3, J4.3, J5.3, J6.3, U1.1
unnamed: J4.2, R3.1
unnamed: J5.2, R5.1
unnamed: J6.2, R8.1
unnamed: J11.2, R11.2
unnamed: J12.2, R12.2
unnamed: J13.2, R10.2
unnamed: J15.1, Q1.2, R13.2, U1.2
unnamed: J16.2, J17.2
unnamed: J18.1, R15.1, U2.1
unnamed: J18.2, J19.2
unnamed: J19.1, U2.3
unnamed: R14.1, R15.2, U2.2
Out1: J8.1, R4.2, R7.2
SollarCell-: C1.1, C2.1, J2.1, J10.4, J14.1, J16.1, J17.1, Q1.3, R2.1, R9.1, R14.2, U1.4, U1.5, U2.11

## KiCad design HighSpeedOpAmpSocket/HighSpeedOpAmpSocket.kicad_pcb

Parts:
C1: 100n; C_0805
C2, C3, C4: 100nF; C_0805
J1, J2: Conn_01x07; Pin_Header_Straight_1x07_Pitch2.54mm
U1, U2, U3, U4: GS8051 - Gansil; SOT-23-5_HandSoldering

Connections:
GND: C1.2, C2.2, C3.2, C4.2, J2.4, U1.2 (V-), U2.2 (V-), U3.2 (V-), U4.2 (V-)
In1+: J1.3, U1.3 (+)
In1-: J1.2, U1.4 (-)
In2+: J1.5, U3.3 (+)
In2-: J1.6, U3.4 (-)
In3+: J2.5, U2.3 (+)
In3-: J2.6, U2.4 (-)
In4+: J2.3, U4.3 (+)
In4-: J2.2, U4.4 (-)
Out1: J1.1, U1.1
Out2: J1.7, U3.1
Out3: J2.7, U2.1
Out4: J2.1, U4.1
Vdd: C1.1, C2.1, C3.1, C4.1, J1.4, U1.5 (V+), U2.5 (V+), U3.5 (V+), U4.5 (V+)

Notes on the sheet:
GS8051 is a large bandwidth unit gain op amp, around 250 MHz Input bias current = 1 pA Current consumption is around 3 mA (per op amp), that is, its not recommended for low power applications. Watch out the power supply! (Vdd-Vss) < 5.5 V
Sot 23-5 Socket

Board: 2 copper layers, 19.1 x 19.0 mm, 10 parts (4 on the bottom side), 14 nets.

## Commit log

2018-12-21 Low voltage DC-DC (MP3414 and bq25504)
2019-01-09 socket NRF51822
2019-01-11 Layout do socket para NRF51822 feito
2019-01-11 Atualizando esquemático do socket nrf
2019-01-31 tentativa de conversor tps
2019-02-01 Deletado adaptador lora da antares nunca utilizado
2019-02-01 finalizado esquematico, falta associar os componentes
2019-02-02 V 0.2 do socket NRF51822 - esquematico e layout
2019-02-04 algumas melhorias
2019-02-12 modificando disposição no esquemático, mas não o esquemático em si
